#pragma once
#include <Arduino.h>
#include "LedMatrix.h"
// Digits and punctuation extracted from Tiny5 Mono BDF, 6x9 cells.
// Copyright 2026 The Tiny5 Project Authors.
// SIL Open Font License 1.1; see Tiny5Mono-OFL.txt.
// Source: https://github.com/Gissio/font_Tiny5Mono at d21e1e7ed7860e73e354c5f052d4130cce603f0e
namespace Tiny5Clock {
static constexpr uint8_t GLYPHS[12][9] = {
  {0x00,0x00,0x0e,0x11,0x15,0x11,0x0e,0x00,0x00}, // 0
  {0x00,0x00,0x04,0x06,0x04,0x04,0x0e,0x00,0x00}, // 1
  {0x00,0x00,0x0e,0x11,0x0c,0x02,0x1f,0x00,0x00}, // 2
  {0x00,0x00,0x1f,0x08,0x0c,0x10,0x0f,0x00,0x00}, // 3
  {0x00,0x00,0x08,0x0c,0x0a,0x1f,0x08,0x00,0x00}, // 4
  {0x00,0x00,0x1f,0x01,0x0f,0x10,0x0f,0x00,0x00}, // 5
  {0x00,0x00,0x1e,0x01,0x0f,0x11,0x0e,0x00,0x00}, // 6
  {0x00,0x00,0x1f,0x10,0x08,0x04,0x02,0x00,0x00}, // 7
  {0x00,0x00,0x0e,0x11,0x0e,0x11,0x0e,0x00,0x00}, // 8
  {0x00,0x00,0x0e,0x11,0x1e,0x10,0x0f,0x00,0x00}, // 9
  {0x00,0x00,0x00,0x04,0x00,0x00,0x04,0x00,0x00}, // :
  {0x00,0x00,0x10,0x08,0x04,0x02,0x01,0x00,0x00}, // /
};
inline int glyph(char ch) {
  if (ch >= '0' && ch <= '9') return ch - '0';
  if (ch == ':') return 10;
  return ch == '/' ? 11 : -1;
}
inline void draw(IkeaMatrix::Frame &frame, const char text[6]) {
  frame.clear();
  for (int i = 0; i < 5; ++i) {
    int g = glyph(text[i]);
    if (g < 0) continue;
    for (int y = 0; y < 9; ++y)
      for (int x = 0; x < 6; ++x)
        if (GLYPHS[g][y] & (1U << x)) frame.drawPixel(6 + i * 6 + x, y);
  }
}
} // namespace Tiny5Clock
