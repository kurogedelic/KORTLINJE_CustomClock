#pragma once
#include <Arduino.h>
#include "LedMatrix.h"

// Bitmap data derived from Press Start 2P at its native 8 px size.
// Copyright 2012 The Press Start 2P Project Authors, SIL Open Font License 1.1.
// Source: https://github.com/google/fonts/tree/main/ofl/pressstart2p
namespace PressStart2PClock {
static constexpr uint8_t GLYPHS[13][8] = {
  {0x1c,0x3e,0x61,0x41,0x43,0x3e,0x1c,0x00}, // 0
  {0x00,0x40,0x42,0x7f,0x7f,0x40,0x40,0x00}, // 1
  {0x62,0x73,0x79,0x59,0x5d,0x4f,0x46,0x00}, // 2
  {0x20,0x61,0x49,0x4d,0x4f,0x7b,0x31,0x00}, // 3
  {0x18,0x1c,0x16,0x13,0x7f,0x7f,0x10,0x00}, // 4
  {0x27,0x67,0x45,0x45,0x45,0x7d,0x38,0x00}, // 5
  {0x3c,0x7e,0x4b,0x49,0x49,0x79,0x30,0x00}, // 6
  {0x03,0x03,0x71,0x79,0x0d,0x07,0x03,0x00}, // 7
  {0x36,0x4f,0x4d,0x59,0x59,0x76,0x30,0x00}, // 8
  {0x06,0x4f,0x49,0x49,0x69,0x3f,0x1e,0x00}, // 9
  {0x00,0x00,0x36,0x36,0x00,0x00,0x00,0x00}, // :
  {0x00,0x08,0x08,0x08,0x08,0x08,0x08,0x00}, // -
  {0x40,0x60,0x30,0x18,0x0c,0x06,0x03,0x01}  // / (date separator)
};

inline uint8_t glyph(char ch) {
  if (ch >= '0' && ch <= '9') return ch - '0';
  if (ch == ':') return 10;
  return ch == '/' ? 12 : 11;
}

inline void draw(IkeaMatrix::Frame &frame, const char text[6]) {
  frame.clear();
  for (int i = 0; i < 5; ++i) {
    const uint8_t *columns = GLYPHS[glyph(text[i])];
    for (int x = 0; x < 8; ++x)
      for (int y = 0; y < 7; ++y)
        if (columns[x] & (1 << y)) frame.drawPixel(1 + i * 8 + x, 1 + y);
  }
}
} // namespace PressStart2PClock
